<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Libraries\FWLib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project\Discover\STM8S105C6-Board.ewp</path>
  </project>
  <batchBuild/>
</workspace>


