# IAR project STM8S105C6-Board.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: inc; ..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\Libraries\STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: STM8S105C6-Board.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../Libraries/Debug/Exe/: FWLib.a
    src/: main.c
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_tim1.c stm8s_tim2.c stm8s_uart2.c
