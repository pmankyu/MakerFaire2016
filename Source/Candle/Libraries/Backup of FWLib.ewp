# IAR project Backup of FWLib.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\Project\Discover\inc; STM8S_StdPeriph_Driver\inc; STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: FWLib.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  group (top)
    STM8_TouchSensing_Driver/src/: stm8_tsl_api.c stm8_tsl_multichannelkey.c stm8_tsl_rc_acquisition.c stm8_tsl_services.c stm8_tsl_singlechannelkey.c stm8_tsl_timebase.c
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c
